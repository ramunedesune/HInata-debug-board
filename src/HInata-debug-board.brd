# Repository ramunedesune/HInata-debug-board

## EAGLE design src/HInata-debug-board.brd

Parts:
D_LEFT: PINHD-1X4; 1X04
D_RIGHT: PINHD-1X4; 1X04
MCU_LEFT: PINHD-1X15; 1X15
MCU_RIGHT: PINHD-1X15; 1X15
U_LEFT: PINHD-1X2; 1X02
U_RIGHT: PINHD-1X2; 1X02

Connections:
5V: D_LEFT.4, MCU_RIGHT.4
COM_LED: D_LEFT.3, MCU_RIGHT.11
CS: D_RIGHT.1, MCU_RIGHT.9
GND: D_LEFT.1, MCU_RIGHT.2, U_LEFT.1, U_LEFT.2, U_RIGHT.1, U_RIGHT.2
INT: D_LEFT.2, MCU_RIGHT.10
MISO: D_RIGHT.2, MCU_RIGHT.7
MOSI: D_RIGHT.3, MCU_RIGHT.6
SCK: D_RIGHT.4, MCU_RIGHT.15

Notes on the sheet:
MCU_F303K8
ひなた

Board: 2 copper layers, 7 parts (0 on the bottom side), 8 nets.

Other parts of the board:
U$1: TYPE.C

## Commit log

2023-11-08 fix Hinata-debug-board
2023-11-08 fix Hinata-debug-board配線
